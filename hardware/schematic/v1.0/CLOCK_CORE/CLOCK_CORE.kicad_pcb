# Repository Han-ZenX/CLOCK

File README.md:

# CLOCK - 高精度频率计后端标准时钟产生模块

<div align="center">

**专业级时间基准解决方案 | 超低相位噪声 | 高稳定度输出**

</div>

---

## 📋 项目概述

本模块是**高精度频率计的后端标准时钟产生系统**，为频率测量提供超稳定的时间基准信号。采用 TI 高端时钟发生器芯片 **LMK5B12204** 和 **LMK1C1102**，实现超低相位噪声和高精度的时钟输出，适用于精密测试测量、通信系统、雷达电子战等对时钟质量要求极高的应用场景。

### 核心特性

- ✅ **超低相位噪声**：专业级时钟性能，满足苛刻的频谱纯度要求
- ✅ **多路可编程输出**：支持 4 路独立可编程差分时钟输出（LVDS/PECL）
- ✅ **高分辨率频率合成**：支持 1Hz-3.3GHz 范围内任意频率设定
- ✅ **参考源冗余切换**：双参考输入 + 自动切换，确保时钟连续性
- ✅ **低抖动性能**：<0.2ps RMS 抖动，提供精准时序基准
- ✅ **EEPROM 存储**：配置断电保存，上电自启动
- ✅ **硬件级稳定性**：工业级设计，宽温工作范围

---

## 🔧 技术规格

### 时钟输出性能

| 参数 | 指标 |
|------|------|
| 输出通道数 | 4 路独立可编程 |
| 输出类型 | LVDS / PECL / CML 差分 |
| 频率范围 | 1MHz ~ 1.25GHz (每路独立) |
| 相位噪声 | < -110dBc @ 1kHz (100MHz 输出) |
| 均方根抖动 | < 0.2ps (12kHz-20MHz 积分) |
| 输出幅度 | 800mVp-p 差分 (典型) |
| 输出阻抗 | 50Ω 匹配 |

### 参考输入

| 参数 | 指标 |
|------|------|
| 主参考输入 | 10MHz 正弦/CMOS 可选 |
| 备参考输入 | 10MHz 或 1PPS 可选 |
| 参考切换 | 自动故障检测与无缝切换 |
| 1PPS 对齐 | 支持秒脉冲同步对齐 |

### 电源要求

- **核心电压**：3.3V ±5%
- **功耗**：典型 1.2W
- **电源抑制比**：>60dB

---

## 🏗️ 系统架构

```
┌─────────────────────────────────────────────────────────────┐
│                    CLOCK 时钟产生模块                        │
├─────────────────────────────────────────────────────────────┤
│                                                               │
│   ┌──────────┐    ┌──────────┐    ┌──────────┐              │
│   │  Ref 1   │    │  Ref 2   │    │  1PPS    │              │
│   │ 10MHz    │    │ 10MHz/   │    │  Pulse   │              │
│   │ 正弦     │    │ PPS      │    │          │              │
│   └────┬─────┘    └────┬─────┘    └────┬─────┘              │
│        │               │                │                   │
│        └───────────────┼────────────────┘                   │
│                        ▼                                    │
│                 ┌───────────────┐                           │
│                 │   LMK5B12204  │  ┌────────────┐          │
│                 │  时钟生成器   │  │            │          │
│                 │  (Main PLL)   │→ │ Out0:100MHz│ LVDS     │
│                 │               │  │            │          │
│                 │               │→ │ Out1:10MHz │ LVDS     │
│                 │               │  │            │          │
│                 │               │→ │ Out2:10MHz │ LVDS     │
│                 │               │  │            │          │
│                 │               │→ │ Out3:1PPS  │ CMOS     │
│                 └───────────────┘  └────────────┘           │
│                        ▲                                      │
│                        │ I²C 配置                            │
│                 ┌───────────────┐                           │
│                 │   LMK1C1102   │  ┌────────────┐           │
│                 │  低抖动分配器 │  │  Status    │ LED 指示    │
│                 │  (Secondary)  │  │  GPIO      │            │
│                 └───────────────┘  └────────────┘           │
│                                                               │
└─────────────────────────────────────────────────────────────┘
```

### 关键组件

| 器件 | 制造商 | 功能描述 |
|------|--------|----------|
| **LMK5B12204** | Texas Instruments | 高性能时钟生成器，内置 4 个超低噪声 PLL |
| **LMK1C1102** | Texas Instruments | 低抖动时钟分配器，提供辅助时钟路径 |
| **SMA 连接器** | Amphenol | RF 输入输出接口，50Ω 匹配 |
| **EEPROM** | Atmel | 非易失性配置存储 |

---

## 📁 目录结构

```
CLOCK-master/
├── firmware/              # 嵌入式固件代码
│   ├── src/
│   │   ├── app/           # 应用层：时钟控制逻辑、状态机
│   │   ├── hal/           # 硬件抽象层：GPIO、I²C、定时器
│   │   ├── drivers/       # 驱动层：LMK5B 寄存器配置
│   │   └── services/      # 服务层：I²C 通信、EEPROM 访问
│   ├── boards/            # 板级配置
│   └── CMakeLists.txt     # CMake 构建配置
├── hardware/              # 硬件设计文件
│   ├── schematic/         # KiCad 原理图
│   │   └── v1.0/
│   │       ├── CLOCK.kicad_sch
│   │       ├── CLOCK.kicad_pcb
│   │       └── ...
│   ├── bom/               # BOM 物料清单
│   ├── gerber/            # PCB 生产文件
│   └── pinout/pinout.md   # 引脚分配说明
├── software/              # 配套软件（可选）
│   ├── desktop/           # PC 配置工具
│   └── mobile/            # 移动端 App
├── docs/                  # 项目文档
│   ├── architecture/      # 架构设计文档
│   ├── user-guide/        # 用户使用手册
│   └── api/               # API 接口文档
├── tests/                 # 测试套件
│   ├── unit/              # 单元测试
│   └── integration/       # 集成测试
└── tools/                 # 工具脚本
    └── scripts/build.py   # 自动化构建脚本
```

---

## 🛠️ 快速开始

### 环境要求

- **编译工具链**：ARM GCC Toolchain (arm-none-eabi-gcc)
- **构建系统**：CMake 3.16+
- **硬件调试器**：JLink / STLink
- **操作系统**：Windows 10+ / Linux / macOS

### 构建固件

```bash
# 克隆仓库
git clone https://github.com/your-repo/CLOCK.git
cd CLOCK

# 创建构建目录
mkdir build && cd build

# 配置项目
cmake .. -DBOARD=default

# 编译 Debug 版本
cmake --build .

# 编译 Release 版本（优化）
cmake --build . --config Release
```

或使用自动化脚本：

```bash
python tools/scripts/build.py --board=default          # Debug 构建
python tools/scripts/build.py --board=v2.0 --release   # Release 构建
python tools/scripts/build.py --flash                  # 构建并烧录
```

### 烧录固件

```bash
# JLink 烧录
JLinkExe -device STM32F4xx -interface swd -speed 4000 -fc 4 -commandER -exitafter1sec firmware/build/app.hex

# 或通过 IDE 烧录
```

---

## 📖 使用说明

### 1. 硬件连接

1. 连接外部 10MHz 参考源到 **J1 (REF_IN)** SMA 接口
2. 可选：连接备用参考源到 **REF_BIST** 接口
3. 连接电源至 **VDD_3V3** (3.3V, 最大 500mA)
4. 观测输出：
   - **J2: OUT0** - 100MHz 主时钟
   - **J3: OUT1** - 10MHz 分频时钟  
   - **J4: OUT2** - 可配置频率
   - **J5: OUT3** - 1PPS 秒脉冲

### 2. 默认配置

上电后，模块将加载 EEPROM 中保存的配置：

- **OUT0**: 100MHz LVDS 差分输出
- **OUT1**: 10MHz LVDS 差分输出
- **OUT2**: 10MHz LVDS 差分输出
- **OUT3**: 1PPS 正方形波输出（上升沿对齐 UTC 时间）

### 3. 配置时钟参数

通过串口命令或 I²C 接口修改时钟参数：

```bash
# 示例：使用串口终端配置
echo "SET_FREQ OUT0 200MHz" > /dev/ttyUSB0    # 设置 OUT0 为 200MHz
echo "SET_FMT OUT1 LVDS" > /dev/ttyUSB0       # 设置 OUT1 格式为 LVDS
echo "SAVE_CONFIG" > /dev/ttyUSB0             # 保存配置到 EEPROM
```

详细命令集请参考 [API 文档](docs/api/).

---

## 🔬 性能验证

### 相位噪声测试

在 100MHz 输出端口测得的典型相位噪声：

| 偏移频率 | 相位噪声 (dBc/Hz) |
|----------|------------------|
| 100 Hz   | -95              |
| 1 kHz    | -110             |
| 10 kHz   | -125             |
| 100 kHz  | -135             |
| 1 MHz    | -145             |
| 10 MHz   | -150             |

### 抖动测试

使用示波器测得 RMS 抖动：**0.15ps** (12kHz-20MHz 带宽)

### 频率稳定度

- 短期稳定度 (ADEV @ 1s): **2×10⁻¹²**
- 长期稳定度 (±0.5ppm/年，配合 TCXO 参考)

---

## 🧪 测试运行

```bash
# 运行单元测试
ctest --output-on-failure

# 运行集成测试（需要硬件）
python tests/integration/run_hwt_tests.py --board=default
```

---

## 📚 参考资料

- **数据手册**：
  - [LMK5B12204 Datasheet (PDF)](https://www.ti.com/lit/ds/symlink/lmk5b12204.pdf)
  - [LMK1C1102 Datasheet (PDF)](https://www.ti.com/lit/ds/symlink/lmk1c1102.pdf)
  
- **应用笔记**：
  - [Clock and Timing Design Guidelines](https://www.ti.com/lit/an)
  - [Low-Jitter Clock Distribution Techniques](docs/architecture/clock_design.pdf)

- **项目文档**：
  - [架构设计文档](docs/architecture/architecture.md)
  - [用户操作手册](docs/user-guide/)

---

## 🛡️ 许可证

本项目采用 **MIT License**。详见 [LICENSE](LICENSE) 文件。

---

## 🤝 贡献指南

欢迎提交 Bug Report 和功能请求！

1. Fork 本仓库
2. 创建特性分支 (`git checkout -b feat/AmazingFeature`)
3. 提交更改 (`git commit -m 'Add some AmazingFeature'`)
4. 推送到分支 (`git push origin feat/AmazingFeature`)
5. 开启 Pull Request

---

## 📞 联系方式

如有技术问题或合作意向，请联系：

- **项目负责人**: [Your Name]
- **邮箱**: [your.email@example.com](mailto:your.email@example.com)
- **GitHub**: [您的 GitHub 地址](https://github.com/your-repo)

---

## ⚠️ 免责声明

本模块为专业级测试设备，仅供研发和技术人员使用。使用者需具备以下能力：

- 熟悉射频电路设计和测试仪器操作
- 理解时钟完整性、EMC/EMI 相关规范
- 遵守实验室安全操作规程

作者不对因不当使用导致的设备损坏或人身伤害承担责任。

---

<div align="center">

**© 2026 CLOCK 项目团队。保留所有权利。**

*基于 Texas Instruments LMK5B12204 + LMK1C1102 专业时钟芯片方案开发*

🎯 **为高精度频率测量提供黄金时间基准** 🎯

</div>

## KiCad design hardware/schematic/v1.0/CLOCK_CORE/CLOCK_CORE.kicad_pcb

Parts:
C9, C10, C11, C13: 100nF; C_0402_1005Metric; Manufacturer Part CL05B104KO5NNNC; LCSC C1525
C12, C56, C58: 10uF; C_0603_1608Metric; Manufacturer Part CL10A106KP8NNNC; LCSC C19702
C57: 1uF; C_0603_1608Metric; Manufacturer Part CL10B105KA8NNNC; LCSC C29936
R13, R14: 1K; R_0402_1005Metric; Manufacturer Part 0402WGF1001TCE; LCSC C11702
R15: 3296W-1-103_C48997937; Manufacturer Part 3296W-1-103; LCSC C48997937
R28: 10R; R_0603_1608Metric; Manufacturer Part 0603WAF100JT5E; LCSC C22859
R29: 0R; R_0603_1608Metric; Manufacturer Part 0603WAF0000T5E; LCSC C21189
R30: 0R; R_0402_1005Metric; Manufacturer Part 0402WGF0000TCE; LCSC C17168
R39: 0R; R_0805_2012Metric; Manufacturer Part 0805W8F0000T5E; LCSC C17477
R40: 0; R_0402_1005Metric; Manufacturer Part 0402WGF0000TCE; LCSC C17168
R41: 0; R_0402_1005Metric; Manufacturer Part 0402WGF0000TCE; LCSC C17168; not fitted
RF10: KH-IPEX-K501-29; Manufacturer Part KH-IPEX-K501-29; LCSC C411563
TP1: Volt TestPoint; TestPoint_Pad_D1.0mm
TP2: TestPoint; TestPoint_Pad_D1.0mm
U1: OCXO_20x20mm; not fitted
U2: OCXO_25.4x25.4mm; DOPFITKR2-10M
U6: REF5040; Manufacturer Part REF5040AIDR; LCSC C46274

Connections:
/LMK5B12204/OCXO_OUT: R40.2, R41.1; also elsewhere on the board
/OCXO/OCXO_MON: C9.2, R13.2
/OCXO/OCXO_MON_RF: C9.1, RF10.4 (SIG)
/OCXO/VCTRL_ADJ: R14.1, R15.2
/OCXO/VREF: R15.3, R29.2
GND: C10.2, C11.1, C12.1, C13.2, C56.2, C57.2, C58.2, R15.1, R41.2, RF10.1 (GND), RF10.2 (GND), RF10.3 (GND), TP2.1 (1_1), U1.3 (GND), U2.2 (GND), U6.4 (GND); also elsewhere on the board
unnamed: R30.2, U1.2 (RF)
unnamed: R39.1, U1.1 (VCC)
unnamed: C57.1, U6.5 (TRIM/NR)
unnamed: C11.2, C56.1, R28.1, U6.2 (VIN)
unnamed: C58.1, R29.1, U6.6 (VOUT)
OCXO_FR: R13.1, R30.1, R40.1, U2.1 (RF)
OCXO_VCC: C10.1, C12.2, R39.2, TP1.1 (1_1), U2.5 (VCC); also elsewhere on the board
VCTRL: C13.1, R14.2, U1.4 (VCTRL/NC), U2.3 (VCTRL)

Notes on the sheet:
OCXO 20x20mm
VREF
OCXO 二选一
OCXO 25.4x25.4mm
50 OHM TRACE

Parts:
C14, C18: 10uF; C_0603_1608Metric; Manufacturer Part CL10A106KP8NNNC; LCSC C19702
C15, C19, C21, C26: 100nF; C_0402_1005Metric; Manufacturer Part CL05B104KO5NNNC; LCSC C1525
C16, C17, C23, C24: 22uF; C_0805_2012Metric; Manufacturer Part CL21A226MOQNNNE; LCSC C98190
C20, C25: 10nF; C_0402_1005Metric; Manufacturer Part CL05B103KB5NNNC; LCSC C15195
C22: TAJB107M010RNJ; Manufacturer Part TAJB107M010RNJ; LCSC C7196
CN1: LAIL-PHC2_54-2P-01-XH-L; Manufacturer Part LAIL-PHC2.54-2P-01-XH-L; LCSC C54905973
D3, D4, D5: LED; LED_0603_1608Metric; Manufacturer Part KT-0603YG; LCSC C2289
F1: BSMD1206C-1300T; Manufacturer Part BSMD1206C-1300T; LCSC C41367225
R16, R21: 12.1K; R_0402_1005Metric; Manufacturer Part 0402WGF1212TCE; LCSC C25852
R17, R22: 3.83K; R_0402_1005Metric; Manufacturer Part 0402WGF3831TCE; LCSC C67236
R18, R23: 100K; R_0402_1005Metric; Manufacturer Part 0402WGF1003TCE; LCSC C25741
R19: 0; R_0805_2012Metric; Manufacturer Part 0805W8F0000T5E; LCSC C17477
R20: 0; R_0805_2012Metric; Manufacturer Part 0805W8F0000T5E; LCSC C17477; not fitted
R42, R43, R46: 2.2K; R_0402_1005Metric; Manufacturer Part 0402WGF2201TCE; LCSC C25879
U3, U4: TPS7A5201RPSR; Manufacturer Part TPS7A5201RPSR; LCSC C2876777

Connections:
/LMK5B12204/PDN: R18.1, U3.8 (PG); also elsewhere on the board
/POWER/+5V_IN: CN1.1, F1.1
/POWER/LDO_3V3_FB: C20.2, R16.2, R17.1, U3.9 (FB)
/POWER/LDO_3V3_NR: C21.1, U3.4 (NR/SS)
/POWER/LDO_OCXO_FB: C25.2, R21.2, R22.1, U4.9 (FB)
/POWER/LDO_OCXO_NR: C26.1, U4.4 (NR/SS)
/POWER/LDO_OCXO_PG: R23.1, U4.8 (PG)
GND: C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C21.2, C22.2, C23.2, C24.2, C26.2, CN1.2, D3.1 (K), D4.1 (K), D5.1 (K), R17.2, R22.2, U3.5 (BIAS), U3.6 (GND), U3.7 (GND), U3.12 (GND), U4.5 (BIAS), U4.6 (GND), U4.7 (GND), U4.12 (GND); also elsewhere on the board
unnamed: D3.2 (A), R46.2
unnamed: D4.2 (A), R42.1
unnamed: D5.2 (A), R43.2
OCXO_VCC: C22.1, R19.2, R20.1, R42.2; also elsewhere on the board

Notes on the sheet:
U3 TPS7A52 5V -> 3.3V 给LMK5B12204供电
OCXO 供电选配 (二者互斥, 严禁同装):
装 R19 = 5V OCXO 直供 / 装 R20 = 3.3V OCXO 经 U4 稳压
U4 TPS7A52 5V -> 3.3V 仅 3.3V OCXO 时装配

Parts:
C1, C2, C3, C4, C5, C6, C7, C8: 100nF; C_0402_1005Metric; Manufacturer Part CL05B104KO5NNNC; LCSC C1525
J1: Conn_Coaxial; SMA_Amphenol_132134-11_Vertical; Manufacturer Part 132134-11; LCSC C5867725
R1, R2, R4, R5, R7, R8, R10, R11: 49.9; R_0402_1005Metric; Manufacturer Part 0402WGF499JTCE; LCSC C25120
R3, R6, R9, R12: 100; R_0402_1005Metric; Manufacturer Part 0402WGF1000TCE; LCSC C25076; not fitted
R31, R32, R33, R34, R35, R36, R37, R38: 0; R_0402_1005Metric; Manufacturer Part 0402WGF0000TCE; LCSC C17168
RF1, RF2, RF3, RF4, RF5, RF6, RF7, RF8, RF9: KH-IPEX-K501-29; Manufacturer Part KH-IPEX-K501-29; LCSC C411563

Connections:
/LMK5B12204/OUT0_N: R31.1; also elsewhere on the board
/LMK5B12204/OUT0_P: R32.1; also elsewhere on the board
/LMK5B12204/OUT1_N: R34.1; also elsewhere on the board
/LMK5B12204/OUT1_P: R33.1; also elsewhere on the board
/LMK5B12204/OUT2_N: R35.1; also elsewhere on the board
/LMK5B12204/OUT2_P: R36.1; also elsewhere on the board
/LMK5B12204/OUT3_N: R37.1; also elsewhere on the board
/LMK5B12204/OUT3_P: R38.1; also elsewhere on the board
/LMK5B12204/PRIREF_P: J1.1 (In), RF9.4 (SIG); also elsewhere on the board
/SIGNAL/IPEX_O0_N: C1.1, R1.2, RF1.4 (SIG)
/SIGNAL/IPEX_O0_P: C2.2, R2.1, RF2.4 (SIG)
/SIGNAL/IPEX_O1_N: C4.2, R5.1, RF4.4 (SIG)
/SIGNAL/IPEX_O1_P: C3.1, R4.2, RF3.4 (SIG)
/SIGNAL/IPEX_O2_N: C5.1, R7.2, RF5.4 (SIG)
/SIGNAL/IPEX_O2_P: C6.2, R8.1, RF6.4 (SIG)
/SIGNAL/IPEX_O3_N: C7.1, R10.2, RF7.4 (SIG)
/SIGNAL/IPEX_O3_P: C8.2, R11.1, RF8.4 (SIG)
/SIGNAL/O0_N: C1.2, R3.2, R31.2
/SIGNAL/O0_P: C2.1, R3.1, R32.2
/SIGNAL/O1_N: C4.1, R6.1, R34.2
/SIGNAL/O1_P: C3.2, R6.2, R33.2
/SIGNAL/O2_N: C5.2, R9.2, R35.2
/SIGNAL/O2_P: C6.1, R9.1, R36.2
/SIGNAL/O3_N: C7.2, R12.2, R37.2
/SIGNAL/O3_P: C8.1, R12.1, R38.2
GND: J1.2 (Ext), R1.1, R2.2, R4.1, R5.2, R7.1, R8.2, R10.1, R11.2, RF1.1 (GND), RF1.2 (GND), RF1.3 (GND), RF2.1 (GND), RF2.2 (GND), RF2.3 (GND), RF3.1 (GND), RF3.2 (GND), RF3.3 (GND), RF4.1 (GND), RF4.2 (GND), RF4.3 (GND), RF5.1 (GND), RF5.2 (GND), RF5.3 (GND), RF6.1 (GND), RF6.2 (GND), RF6.3 (GND), RF7.1 (GND), RF7.2 (GND), RF7.3 (GND), RF8.1 (GND), RF8.2 (GND), RF8.3 (GND), RF9.1 (GND), RF9.2 (GND), RF9.3 (GND); also elsewhere on the board

Notes on the sheet:
PRIREF_P
OUT0
OUT2
OUT1

Parts:
C27, C28, C29, C33, C36, C39, C42, C47, C50: 10uF; C_0402_1005Metric; Manufacturer Part CL05A106MP8NUB8; LCSC C307415
C30: 470nF; C_0402_1005Metric; Manufacturer Part CL05A474KA5NNNC; LCSC C92361
C31, C32, C34, C35, C37, C38, C40, C43, C45, C46, C48, C49, C51, C52, C53, C54, C55, C59: 100nF; C_0402_1005Metric; Manufacturer Part CL05B104KO5NNNC; LCSC C1525
C41, C44: 1uF; C_0402_1005Metric; Manufacturer Part CL05A105KA5NQNC; LCSC C52923
D1, D2: LED; LED_0603_1608Metric; Manufacturer Part KT-0603YG; LCSC C2289
FB1, FB2, FB3, FB4, FB5, FB6, FB7: 220 ohm@100mhz; L_0603_1608Metric; Manufacturer Part MPZ1608S221ATA00; LCSC C76815
H1: HX_PH254-01-03-Z-L11_5_PCB_PIN_HEADER; Manufacturer Part HX PH254-01-03-Z-L11.5 pcb pin header; LCSC C52016391
R24, R53: 0; R_0402_1005Metric; Manufacturer Part 0402WGF0000TCE; LCSC C17168
R25: 10K; R_0603_1608Metric; Manufacturer Part 0603WAF1002T5E; LCSC C25804
R26, R27: 4.7K; R_0603_1608Metric; Manufacturer Part 0603WAF4701T5E; LCSC C23162
R51, R52: 499; R_0402_1005Metric; Manufacturer Part 0402WGF4990TCE; LCSC C4125
U5: LMK5B12204; VQFN-48-1EP_7x7mm_P0.5mm_EP5.15x5.15mm_ThermalVias; Manufacturer Part LMK5B12204RGZR; LCSC C3611975

Connections:
/DEBUG/SCL: R26.1, U5.26 (SCL/SCK); also elsewhere on the board
/DEBUG/SDA: R27.1, U5.25 (SDA/SDI); also elsewhere on the board
/LMK5B12204/HW_SW_CTRL: R24.2, U5.9 (HW_SW_CTRL)
/LMK5B12204/OCXO_OUT: U5.31 (XO_P); also elsewhere on the board
/LMK5B12204/OUT0_N: U5.16 (OUT0_N); also elsewhere on the board
/LMK5B12204/OUT0_P: U5.17 (OUT0_P); also elsewhere on the board
/LMK5B12204/OUT1_N: U5.21 (OUT1_N); also elsewhere on the board
/LMK5B12204/OUT1_P: U5.20 (OUT1_P); also elsewhere on the board
/LMK5B12204/OUT2_N: U5.41 (OUT2_N); also elsewhere on the board
/LMK5B12204/OUT2_P: U5.42 (OUT2_P); also elsewhere on the board
/LMK5B12204/OUT3_N: U5.44 (OUT3_N); also elsewhere on the board
/LMK5B12204/OUT3_P: U5.45 (OUT3_P); also elsewhere on the board
/LMK5B12204/PDN: R53.1; also elsewhere on the board
/LMK5B12204/PRIREF_P: U5.6 (PRIREF_P); also elsewhere on the board
/LMK5B12204/SYNCN: H1.2, R25.2, U5.12 (GPIO0/SYNCN)
CAP_DIG: C27.2, U5.3 (CAP_DIG)
CAP_PLL1: C28.2, U5.28 (CAP_PLL1)
CAP_PLL2: C29.2, U5.35 (CAP_PLL2)
GND: C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.1, C53.1, C54.1, C55.1, C59.1, D1.1 (K), D2.1 (K), H1.3, R24.1, U5.7 (PRIREF_N), U5.8 (REFSEL), U5.24 (GPIO1/SCS), U5.32 (XO_N), U5.49 (EPAD); also elsewhere on the board
LF1: C30.2, U5.29 (LF1)
LF2: C31.2, U5.34 (LF2)
unnamed: D1.2 (A), R51.2
unnamed: D2.2 (A), R52.2
unnamed: C45.2, R53.2, U5.13 (PDN)
STATUS0: R51.1, U5.1 (STATUS0)
STATUS1: R52.1, U5.2 (STATUS1/_FDEC)
VDDDIG: C51.2, FB5.2, U5.4 (VDD_DIG)
VDDIN: C33.2, C52.2, FB1.2, U5.5 (VDD_IN)
VDDO0_1: C34.2, C37.2, C47.2, FB6.2, U5.18 (VDDO_0), U5.19 (VDDO_1)
VDDO2_3: C40.2, C43.2, C48.2, C50.2, C55.2, FB7.2, U5.37 (VDDO_2), U5.40 (VDDO_2), U5.43 (VDDO_3), U5.46 (VDDO_3)
VDDPLL1: C39.2, C53.2, FB3.2, U5.27 (VDD_PLL1)
VDDPLL2: C42.2, C54.2, FB4.2, U5.36 (VDD_PLL2)
VDDXO: C36.2, C59.2, FB2.2, U5.33 (VDD_XO)

Parts:
H2, H3, H4, H5: MountingHole_Pad; MountingHole_3.2mm_M3_Pad
J3: Conn_01x04_Socket; PinHeader_1x04_P2.54mm_Vertical; Manufacturer Part 2.54-1*4; LCSC C5116483

Connections:
/DEBUG/SCL: J3.4; also elsewhere on the board
/DEBUG/SDA: J3.3; also elsewhere on the board
GND: H2.1 (1_1), H3.1 (1_1), H4.1 (1_1), H5.1 (1_1), J3.2; also elsewhere on the board

Notes on the sheet:
I2C
HOLE

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
Board: 4 copper layers, 70.0 x 70.0 mm, 145 parts (22 on the bottom side), 73 nets.

Notices in the files:
README.md:
License: MIT
